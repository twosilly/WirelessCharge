# Keil uVision project WirelessCharge.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: WirelessCharge
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GVM32F030x8
  c include: ..\Libraries\CMSIS\Device\GV\gvm32f030;..\Libraries\CMSIS\Include;..\User\BSP;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group CMSIS
    ../Libraries/CMSIS/Device/GV/gvm32f030/startup/: startup_gvm32f030.s
    ../Libraries/CMSIS/Device/GV/gvm32f030/: system_gvm32f030.c
  group User
    ../User/: main.c Control.c
  group BSP
    ../User/BSP/: BSP.c LED.c UART.c SysTick.c MagneticField.c
    ../User/: Qi.c
